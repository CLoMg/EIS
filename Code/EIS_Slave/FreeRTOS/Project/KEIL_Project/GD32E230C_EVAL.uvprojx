# Keil uVision project GD32E230C_EVAL.uvprojx, settings and files
target GD32E230C_EVAL (6120000::V6.12::.\ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_EVAL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230 __CNUC__
  c include: ..\..\Project;..\..\..\Library\Utilities;..\..\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\include;..\..\Firmware\GD32E230_standard_peripheral\Include;..\..\..\Library\Firmware\GD32E230_standard_peripheral\Include;..\..\..\Library\Firmware\CMSIS\GD\GD32E230\Include;..\..\Third_Party\FreeRTOSv10.1.1\FreeRTOS\Source\portable\GCC\ARM_CM0;..\..\..\Library\Firmware\CMSIS\GD\GD32E230\Include;..\..\FML\inc;..\..\HAL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: gd32e230_it.c main.c
  group FML
    ../../FML/src/: ec_tb600.c temp.c ws_gas.c dsl_08.c scd4x_i2c.c sensirion_common.c sensirion_i2c.c
  group HAL
    ../../HAL/src/: uart.c spi.c myiic.c sensirion_i2c_hal.c
  group GD32E230_Peripherals
    ../../../Library/Firmware/GD32E230_standard_peripheral/Source/: gd32e230_adc.c gd32e230_cmp.c gd32e230_crc.c gd32e230_dbg.c gd32e230_dma.c gd32e230_exti.c gd32e230_fmc.c gd32e230_fwdgt.c gd32e230_gpio.c gd32e230_i2c.c gd32e230_misc.c gd32e230_pmu.c gd32e230_rcu.c gd32e230_rtc.c gd32e230_spi.c gd32e230_syscfg.c gd32e230_timer.c gd32e230_usart.c gd32e230_wwdgt.c
  group FreeRTOS
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Third_Party/FreeRTOSv10.1.1/FreeRTOS/Source/portable/GCC/ARM_CM0/: port.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32e230/Source/: system_gd32e230.c
  group Board
    ../../../Library/Utilities/: gd32e230c_eval.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32e230/Source/ARM/: startup_gd32E230.s
software components: CMSIS:CORE 5.3.0
