# Keil uVision project EIS_Master_GD32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EIS_Master_GD32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\CORE\GD\GD32F10x\Include;..\CORE;..\FWLIB\Include;..\USER;..\MiddleWare\Third_Part\Board;..\MiddleWare\Third_Part\FreeRTOS\include;..\MiddleWare\Third_Part\FreeRTOS\portable\ARM_CM3;..\MiddleWare\Direction;..\MiddleWare\LED;..\MiddleWare\LORA_Module;..\MiddleWare\Slave;..\MiddleWare\SPI;..\MiddleWare\FSM;..\HAL\inc;..\MiddleWare\Msg_Handler;..\MiddleWare\IAP;..\HARDWARE\Battery;..\HARDWARE\SCD4x;..\HARDWARE\DSL_08
  library: MicroLIB
  memory RVCT4: ROM 0x8002800 size 0x6c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: gd32f10x_it.c main.c systick.c
  group CMSIS
    ../CORE/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../FWLIB/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../CORE/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group FreeRTOS
    ../MiddleWare/Third_Part/FreeRTOS/: croutine.c event_groups.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
    ../MiddleWare/Third_Part/FreeRTOS/include/: FreeRTOSConfig.h
    ../MiddleWare/Third_Part/FreeRTOS/portable/ARM_CM3/: port.c
    ../MiddleWare/Third_Part/FreeRTOS/portable/MemMang/: heap_4.c
  group Board
    ../MiddleWare/Third_Part/Board/: gd32f10x_eval.c
  group Module
    ../MiddleWare/Direction/: direct.c
    ../MiddleWare/FSM/: fsm.c
    ../MiddleWare/LED/: led.c
    ../MiddleWare/LORA_Module/: lora_module.c
    ../MiddleWare/Slave/: slave.c
    ../MiddleWare/SPI/: spi.c
    ../MiddleWare/Msg_Handler/: msg_handler.c
    ../MiddleWare/IAP/: iap.c
    ../HARDWARE/Battery/: battery.c
    ../HARDWARE/SCD4x/: scd4x_i2c.c sensirion_common.c sensirion_i2c.c
    ../HARDWARE/DSL_08/: dsl_08.c
  group HAL
    ../HAL/src/: uart.c timer.c rs485.c sensirion_i2c_hal.c myiic.c
