# Keil uVision project tunnel gas.uvprojx, settings and files
target STM32F1xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tunnel_gas_stm32f1xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\User;..\Hardware\MH4xx;..\CM3;..\System_F1\delay;..\System_F1\sys;..\System_F1\usart;..\Hardware\RS485;..\Hardware\Max30105
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c Device Type.txt
  group Hardware
    ../Hardware/MH4xx/: mh4xx.c
    ../Hardware/TIMER/: timer.c
    ../Hardware/Command/: command.c
    ../Hardware/STMFLASH/: stmflash.c
    ../Hardware/SHT3x/: sht3x.c
    ../Hardware/WDG/: wdg.c
    ../Hardware/EC20/: ec20.c
    ../Hardware/PMS7003/: pms7003.c
    ../Hardware/LED/: led.c
    ../Hardware/USR-K7/: usr_k7.c
    ../Hardware/Max30105/: max30105.c
    ../Hardware/ADC/: adc.c
    ../Hardware/IIC/: myiic.c
    ../Hardware/MMD/: mmdxx.c
    ../Hardware/Motor/: motor.c
    ../Hardware/MODBUS/: modbus.c
    ../Hardware/UESTC/: uestc_gas.c
    ../Hardware/LORA/: LORA.c
  group FWLIB_F4
    ../STM32F40x_FWLib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_adc.c
  group CoreM4
    ../CM4/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group System_F4
    ../System_F4/delay/: delay.c
    ../System_F4/sys/: sys.c
    ../System_F4/usart/: usart.c
    ../System_F4/I2C/: i2c.c
    ../System_F4/RS485/: rs485.c
    ../System_F4/upgrade/: upgrade.c
    ../System_F4/task/: task.c
target STM32F4xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tunnel_gas_stm32f4xx +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o    ..\bin\tunnel_gas_stm32f4xx.bin ..\Objects\tunnel_gas_stm32f4xx.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Hardware\MH4xx;..\CM4;..\STM32F40x_FWLib\inc;..\System_F4\delay;..\System_F4\sys;..\System_F4\usart;..\Hardware\Max30105;..\System_F4\I2C;..\Hardware\TIMER;..\Hardware\Command;..\Hardware\STMFLASH;..\Hardware\SHT3x;..\Hardware\WDG;..\Hardware\EC20;..\Hardware\PMS7003;..\Hardware\LED;..\Hardware\USR-K7;..\canvas\sdk\inc;..\Hardware\ADC;..\Hardware\IIC;..\Hardware\MMD;..\Hardware\Motor;..\System_F4\RS485;..\Hardware\MODBUS;..\Hardware\UESTC;..\Hardware\LORA;..\Hardware\ADC;..\System_F4\upgrade;..\System_F4\task
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --libpath "E:\Keil_v5\ARM\ARMCC\lib"
